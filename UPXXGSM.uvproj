# Keil uVision project UPXXGSM.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UP400_GSM +hex
  c flags: Optim=1
  c include: .\Source\Comm;.\Source\App
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./Source/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ./Source/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group APP
    ./Source/App/: GPRS.c gsm.c IIC.c mwork.c timer.c uart.c work.c main.c comm.c ucs2.c gsmcomm.c
  group Read
    ./Source/: 说明.txt
  group Comm
    ./Source/Comm/: wxcw.C ModbusM.C Configuration.C
